# Keil uVision project NixieTube.uvproj, settings and files
target NixieTube (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NixieTube +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./main/: main.c sysParameter.h
  group delay
    ./delay/: timeDebug.c timeDebug.h
