# Keil uVision project timeDebug.uvproj, settings and files
target timeDebug (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: timeDebug +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: timeDebug.c timeDebug.h main.c
