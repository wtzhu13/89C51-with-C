# Keil uVision project serialPortCommunication.uvproj, settings and files
target serialPortCommunication (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: serialPortCommunication +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./main/: main.c
