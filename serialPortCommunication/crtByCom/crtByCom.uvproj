# Keil uVision project crtByCom.uvproj, settings and files
target crtByCom (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: crtByCom +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./main/: main.c sysParameter.h
  group delay
    ./delay/: timeDebug.c timeDebug.h
  group nixieTube
    ./nixieTube/: show.c show.h
