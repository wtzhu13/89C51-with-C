# Keil uVision project infraredCrtl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: infraredCrtl +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./main/: main.c sysParameter.h
  group delay
    ./delay/: timeDebug.c timeDebug.h
  group 1602Ctrl
    ./1602Ctrl/: 1602Crtl.c 1602Crtl.h
  group infrared
    ./infrared/: infrared.c infrared.h
