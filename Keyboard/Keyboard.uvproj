# Keil uVision project Keyboard.uvproj, settings and files
target Keyboard (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./main/: main.c sysParameter.h
  group delay
    ./delay/: timeDebug.c timeDebug.h
  group keyboard
    ./keboard/: independent.c matrix.c independent.h matrix.h
  group nixie_tube
    ./nixie_tube/: show.c show.h
  group beep
    ./beep/: beep.c beep.h
